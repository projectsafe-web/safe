# Keil uVision project Lcd8bitTouch380.uvproj, settings and files
target QD-TFT (MCS-51)
  device: C8051F380 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: ceshi
  c flags: Optimize=8 SizeSpeed=1
  c include: .\font;.\LCD;.\sys;.\touch;.\GUI;.\USER
  group USER
    ./: main.c init380.c SYS19.LIB Isd4004Spi.c fingerprint.c
